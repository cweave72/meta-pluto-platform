# Busybox configuration fragments for the Pluto platform.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://pluto.cfg"
