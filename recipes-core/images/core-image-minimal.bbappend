# The FIT image holds the root filesystem as a gzip cpio archive (initramfs).
IMAGE_FSTYPES:pluto = "cpio.gz"
