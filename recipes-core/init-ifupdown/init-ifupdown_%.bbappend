# Replace /etc/network/interfaces: loopback and the USB network gadget.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
